Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Número de proyecto
Time: 2025-02-13T11:28:18+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.0.296 - Exporter 23.0.0.296 - Default UI

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Otros - Categoría: Información de proyecto; Dirección de proyecto: ## CalleCiudad, Estado CP; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: ## CalleCiudad, Estado CP; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey: Nivel:Extremo inicial 8 mm, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Cotas - Altura de cálculo: 0 mm
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes
Otros - Categoría: Niveles; Familia: Nivel; Familia y tipo: Nivel: Extremo inicial 8 mm; ID de tipo: 27; Tipo: Extremo inicial 8 mm
Restricciones - Alzado: 0 mm
Datos de identidad(Type) - Nombre de tipo: Extremo inicial 8 mm
Gráficos(Type) - Color: 0; Grosor de línea: 1; Patrón de línea: Centro; Símbolo: M_Extremo inicial de nivel - Círculo; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes
Otros(Type) - Categoría: Niveles; Nombre de familia: Nivel
Restricciones(Type) - Base de elevación: Punto base del proyecto

# IfcBuildingElementProxy: Familia2:TN24C, Familia2:TN24C:208153
In: Nivel 1
Type - Material: Acero (7)
Type - Cotas - PESO_BRUTO: 0
Type - Datos de identidad - Descripción: CIMENTACIONES; Fabricante: Noxifer; Modelo: TN24C; Nombre de tipo: TN24C; URL: www.noxifer.com
Type - Otros - Categoría: Modelos genéricos; Nombre de familia: Familia2
Type - Restricciones - Elevación por defecto: 0 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Noxifer
Pset_BuildingElementProxyCommon - Reference: TN24C; sets with these values: 2
Cotas - Área: 0.0320129 m2; Volumen: 0.000261501 m3
Otros - Familia: Familia2; Familia y tipo: Familia2: TN24C; ID de tipo: 208138; Tipo: TN24C
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Ninguno; Desfase desde el anfitrión: 0 mm; Elevación desde el nivel: 0 mm; Se mueve con elementos cercanos: no
